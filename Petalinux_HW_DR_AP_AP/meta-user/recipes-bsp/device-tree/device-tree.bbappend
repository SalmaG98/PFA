FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://system-user.dtsi \
		file://dpu.dtsi \
		file://openamp.dtsi"
